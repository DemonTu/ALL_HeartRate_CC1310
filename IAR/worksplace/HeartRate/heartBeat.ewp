# IAR project heartBeat.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC1310F128 TexasInstruments CC1310F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: TI_DRIVERS_I2C_INCLUDED
  ICCARM.IExtraOptions: -f; configPkg/compiler.opt.defs; --diag_suppress=Pa050; -I$CC13XXWARE$; -Dewarm; --debug; --silent; -Ismartrf_settings
  ICCARM.CCIncludePath2: C:\work\source\ALL_HeartRate_CC1310\software\IAR\worksplace\HeartRate\Application\common; C:\work\source\ALL_HeartRate_CC1310\software\IAR\worksplace\HeartRate\Application\Drivers\UART; C:\work\source\ALL_HeartRate_CC1310\software\IAR\worksplace\HeartRate\Application\Drivers\OLED; C:\work\source\ALL_HeartRate_CC1310\software\IAR\worksplace\HeartRate\Application\Drivers\I2C; C:\work\source\ALL_HeartRate_CC1310\software\IAR\worksplace\HeartRate\Application\userApp; C:\work\source\ALL_HeartRate_CC1310\software\IAR\worksplace\HeartRate\Application\Drivers\RF; C:\work\source\ALL_HeartRate_CC1310\software\IAR\worksplace\HeartRate\Application\Drivers\swTool; C:\work\source\ALL_HeartRate_CC1310\software\IAR\worksplace\HeartRate\Application\Drivers\ADC
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: heartBeat.bin
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: heartBeat.out
  ILINK.IlinkIcfFile: $PROJ_FNAME$_CC1310_LAUNCHXL.icf
  ILINK.IlinkExtraOptions: -f; configPkg/linker.cmd; $CC13XXWARE$/driverlib/bin/iar/driverlib.lib; --silent; --cpu=Cortex-M3; --entry=__iar_program_start; --redirect; _Printf=_PrintfSmall; --redirect; _Scanf=_ScanfSmall
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group RF Packet TX/Configuration files
    ./: heartBeat.cfg
  group RF Packet TX/Documentation
    ./: rfPacketTx_readme.txt
  group RF Packet TX/Drivers/ADC
    Application/Drivers/ADC/: scif.c scif.h scif_framework.c scif_framework.h scif_osal_tirtos.c scif_osal_tirtos.h
  group RF Packet TX/Drivers/I2C
    Application/Drivers/I2C/: bsp_i2c.c bsp_i2c.h
  group RF Packet TX/Drivers/OLED
    Application/Drivers/OLED/: font.h OLED_Driver.c OLED_Driver.h
  group RF Packet TX/Drivers/RF
    Application/Drivers/RF/: EasyLink.c EasyLink.h smartrf_settings_predefined.c smartrf_settings_predefined.h
  group RF Packet TX/Drivers/SWTOOL
    Application/Drivers/swTool/: ALSW_BigSmallEnding.c ALSW_BigSmallEnding.h ALSW_CheckSum.c ALSW_CheckSum.h
  group RF Packet TX/Drivers/UART
    Application/Drivers/UART/: bsp_uart.c bsp_uart.h
  group RF Packet TX/Header files
    ./: Board.h CC1310_LAUNCHXL.h
    smartrf_settings/: smartrf_settings.h
  group RF Packet TX/Header files/Common
    Application/common/: config.h includes.h st_defs.h
  group RF Packet TX/Source files
    ./: CC1310_LAUNCHXL.c ccfg.c heartBeat_CC1310_LAUNCHXL.icf main.c
    Application/userApp/: OELD_UserApp.c RFQueue.c SystemMasterTask.c UserHeartBeatApp.c userPowerManage.c UserRfApp.c UserRfProtocol.c
    smartrf_settings/: smartrf_settings.c
